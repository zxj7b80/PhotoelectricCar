# IAR project 2014.08.22.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PE V2.0 2014.08.05 wandaosudu.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: 2014.08.22.srec
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources/C
    src/Sources/C/: isr.c main.c
  group Sources/C/Component_C
    src/Sources/C/Component_C/: adc.c button.c control.c decoder.c delay.c gpio.c i2c.c light.c LQ12864.c PID.c pit.c pwm.c uart.c wdog.c
  group Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Sources/H
    src/Sources/H/: hw_adc.h includes.h
  group Sources/H/Component_H
    src/Sources/H/Component_H/: adc.h button.h control.h decoder.h delay.h gpio.h i2c.h light.h LQ12864.h PID.h pit.h pwm.h uart.h wdog.h
  group Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
    src/Sources/H/: mma8451.h
